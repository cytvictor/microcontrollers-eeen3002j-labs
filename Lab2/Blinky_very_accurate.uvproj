# Keil uVision project Blinky_very_accurate.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Blinky_very_accurate
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Source/: utils.s main.s timer.s
